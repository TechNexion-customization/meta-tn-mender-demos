DEPENDS += "mender-dir-overlay-native"
